## Kernel-Modules/defconfig
```kconfig
CONFIG_PREEMPT_RT=y
CONFIG_HIGH_RES_TIMERS=y
CONFIG_IIO=y
CONFIG_VIDEO_V4L2=y
CONFIG_CAN=y
CONFIG_PWM=y
CONFIG_SPI=y
CONFIG_I2C=y
CONFIG_SERIAL_8250=y
```
